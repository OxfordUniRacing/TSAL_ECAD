File: LED/TSAL_LED.kicad_pcb (KiCad board)
At the start: 2 copper layers, 147 x 50 mm, 90 parts, among them J101 Conn_01x04_Male

Commit message: hv sense v2
Other:
- net class Default removed
