# Repository OxfordUniRacing/TSAL_ECAD

## KiCad design Main/TSAL.kicad_pcb

Board: 2 copper layers, 140.0 x 70.0 mm, 155 parts (1 on the bottom side), 86 nets.

Parts:
C1, C2, C3, C4, C6, C15, C16, C17, C20, C34, C37, C39, C40, C42: 0.1uF; C_0402_1005Metric
C5: 2.2uF; C_0805_2012Metric
C7, C8, C22, C23, C24: 10uF; C_1210_3225Metric
C9, C10, C11, C12, C13, C14: 22uF; C_0805_2012Metric
C18, C19: 220uF; CP_Elec_8x10.5
C21, C25, C27: 1uF; C_0402_1005Metric
C26: 100pF; C_0402_1005Metric
C28, C38, C41, C43: 1nF; C_0402_1005Metric
C29, C30, C31: 100uF; C_1210_3225Metric
C32, C33, C35, C36: 200F; CP_Radial_D30.0mm_P10.00mm_SnapIn
D1: D_SOD-123
D2: SMF4L15A; D_SOD-123
D3: D_SOD-323
F1: 6A; Fuseholder_Littelfuse_Nano2_154x
F2: 1A; Fuseholder_Littelfuse_Nano2_154x
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3_Pad
J1: Micro-Fit; Molex_Micro-Fit_3.0_43045-0412_2x02_P3.00mm_Vertical
J2: Mini-SPOX; Molex_SPOX_5267-03A_1x03_P2.50mm_Vertical
J3: Mini-SPOX; Molex_SPOX_5267-04A_1x04_P2.50mm_Vertical
J4: Mini-SPOX; Molex_SPOX_5267-06A_1x06_P2.50mm_Vertical
J5: Mini-SPOX; Molex_SPOX_5267-02A_1x02_P2.50mm_Vertical
JP1: 0; R_0402_1005Metric
L1: 1.5uH; L_Bourns-SRN4018
L2: 4.7uH; L_Bourns-SRN4018
L3: 2.2uH; L_Bourns-SRN8040_8x8.15mm
L4: 3.3uH; L_Bourns_SRP1245A
Q1, Q2, Q3, Q4, Q5: IRLML2502; SOT-23
Q6: BSC0904NSI; TDSON-8-1
Q7, Q8: BSC0902NSI; TDSON-8-1
Q9, Q11: MJD122; TO-252-2
Q10: NPN; SOT-23
Q12: PNP; SOT-23
R1, R2, R6, R7, R8, R9, R10, R11, R40, R47: 100k; R_0402_1005Metric
R3: 10k; R_0805_2012Metric
R4, R14, R19, R20, R21, R22, R23, R27, R30, R33, R36, R37, R42, R49, R50: 10k; R_0402_1005Metric
R5, R16: 100k; R_0805_2012Metric
R12, R32: 0.006; R_2512_6332Metric
R13, R31: 56k; R_0402_1005Metric
R15: 1M; R_0805_2012Metric
R17: 180k; R_0805_2012Metric
R18, R29: 68k; R_0805_2012Metric
R24, R34, R39, R45: 47k; R_0402_1005Metric
R25, R26: 0; R_0402_1005Metric
R28, R46, R51: 15k; R_0805_2012Metric
R35: 12k; R_0805_2012Metric
R38, R41, R43, R44, R48: 1k; R_0402_1005Metric
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8, TP9, TP10, TP11: TestPoint_Loop_D2.50mm_Drill1.0mm
U1, U2: 74HC08; TSSOP-14_4.4x5mm_P0.65mm
U3: LMC555; VSSOP-8_3.0x3.0mm_P0.65mm
U4: TPS562200; SOT-23-6
U5: TPS63020
U6: MAX40200AUK; SOT-23-5
U7: INA180A3; SOT-23-5
U8: TLV9104; TSSOP-14_4.4x5mm_P0.65mm
U9: LM25117; ETSSOP-20-1EP_4.4x6.5mm_P0.65mm_EP3x4.2mm
U10, U11: TLV431; SOT-23
ZZ1, ZZ2, ZZ3, ZZ4, ZZ5, ZZ6, ZZ7, ZZ8: Trace_0.2mmx0.6mm

Connections:
+5V: C9.1, C10.1, C20.1, D1.2, L2.2, R13.1, R39.2, R45.2, U7.5
/AUX_1: J4.1, R9.1, U1.5, U2.5
/AUX_2: J4.2, R8.1, U1.10, U2.9
/AUX_3: J4.3, R7.1, U1.9, U2.10
/Dash_LED-: J5.2, Q5.3
/GLED-: J3.4, Q1.3
/Power/BAL_CTRL1: C40.1, Q11.1, R44.1, R47.2, TP10.1
/Power/BAL_CTRL2: C39.1, Q9.1, R38.1, R40.2, TP9.1
/Power/BUCK_VCC: C25.1, D3.2, JP1.1, R42.1, R43.1, U9.3, U9.16
/Power/CAP_D1: R27.2, R39.1, R41.2, U8.7, U8.12
/Power/CAP_D2: R19.2, R45.1, R48.2, U8.1, U8.10
/Power/CM: R33.1, R50.1, TP6.1, U9.10
/Power/COMP: C26.1, C28.1, U9.9
/Power/CS: U9.12, ZZ4.1
/Power/CSG: U9.13, ZZ6.1
/Power/DEMB: JP1.2, U9.2
/Power/FB: C26.2, R24.2, R29.2, R35.1, U9.8
/Power/HB: C27.1, D3.1, U9.19
/Power/HO: R25.2, U9.18
/Power/IN_CS+: U7.3, ZZ1.1
/Power/IN_CS-: U7.4, ZZ2.1
/Power/I_IN: R46.1, TP4.1, U7.1
/Power/LO: R26.2, U9.15
/Power/RAMP: C38.1, Q12.3, R31.2, U9.11
/Power/RT: R28.1, R34.1, U9.5
/Power/SS: C34.1, U9.4
/Power/SW: C27.2, L4.1, Q6.1, Q6.2, Q6.3, Q8.5, R31.1, U9.17
/Power/SW_IN: C19.1, C22.1, C23.1, C24.1, L3.2, Q6.5
/Power/UVLO: R18.2, R20.1, U9.1
/Power/VCAP1: C32.2, C33.2, C35.1, C36.1, Q9.3, Q11.2, TP8.1, ZZ5.1
/Power/VCAP2: C16.1, C32.1, C33.1, Q7.5, Q9.2, TP7.1, U6.1, U6.3, ZZ3.1
/Power/V_CHARGE: C29.1, C30.1, C31.1, L4.2, Q7.1, Q7.2, Q7.3, R29.1
/Power/V_IN: C7.1, C8.1, C18.1, C21.1, C42.1, L3.1, Q7.4, R12.2, R18.1, U4.3, U4.5, U8.4, U9.20, ZZ2.2
/RLED-: J3.2, Q2.3
/Sense_1: J2.2, R11.1, U1.1, U2.1
/Sense_2: J4.6, R10.1, U1.2, U2.2
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C21.2, C22.2, C23.2, C24.2, C25.2, C29.2, C30.2, C31.2, C35.2, C36.2, C39.2, C40.2, C42.2, D2.2, J1.1, J1.3, J2.1, J4.5, Q2.2, Q3.2, Q4.2, Q5.2, Q11.3, R1.2, R2.2, R6.2, R7.2, R8.2, R9.2, R10.2, R11.2, R14.2, R17.2, R23.1, R32.2, R37.1, R40.1, R47.1, TP3.1, TP5.1, TP11.1, U1.7, U2.7, U3.1, U4.1, U5.2, U5.15, U6.2, U8.11, U9.14, U9.21, ZZ6.2, ZZ7.2, ZZ8.1
GNDA: C20.2, C34.2, C37.2, C38.2, C41.2, C43.2, Q10.2, R20.2, R34.2, R35.2, R49.2, R51.2, U7.2, U9.6, U10.3, U11.3, ZZ7.1
unnamed: C4.1, U3.5
unnamed: C5.1, R5.2, U3.2, U3.6
unnamed: C6.1, L2.1, U4.2
unnamed: C6.2, U4.6
unnamed: C11.1, C12.1, C17.1, D1.1, TP1.1, U5.10, U5.11, U6.5
unnamed: C13.1, C14.1, F2.2, R15.1, U5.4, U5.5
unnamed: C15.1, U5.1, U5.12, U5.13
unnamed: C28.2, R24.1
unnamed: C37.1, Q10.1, R33.2
unnamed: C41.1, R46.2, R49.1, U10.1
unnamed: C43.1, R50.2, R51.1, U11.1
unnamed: D2.1, F1.1, R12.1, ZZ1.2
unnamed: L1.1, U5.8, U5.9
unnamed: L1.2, U5.6, U5.7
unnamed: Q1.1, R1.1, U1.11
unnamed: Q1.2, Q3.3
unnamed: Q2.1, R2.1, U3.3
unnamed: Q3.1, Q4.1, Q5.1, R6.1, U2.11
unnamed: Q4.3, R4.2, U3.4
unnamed: Q6.4, R25.1
unnamed: Q8.1, Q8.2, Q8.3, R32.1, ZZ4.2
unnamed: Q8.4, R26.1
unnamed: Q10.3, R28.2
unnamed: Q12.1, R42.2, U10.2, U11.2
unnamed: Q12.2, R43.2
unnamed: R3.2, R5.1, U3.7
unnamed: R13.2, R14.1, U4.4
unnamed: R15.2, R16.1
unnamed: R16.2, R17.1, U5.3
unnamed: R19.1, R21.2, U8.3
unnamed: R21.1, ZZ3.2
unnamed: R22.1, R30.1, ZZ5.2
unnamed: R22.2, R23.2, U8.2
unnamed: R27.1, R30.2, U8.5
unnamed: R36.1, ZZ8.2
unnamed: R36.2, R37.2, U8.6
unnamed: R38.2, U8.8
unnamed: R41.1, U8.9
unnamed: R44.2, U8.14
unnamed: R48.1, U8.13
unnamed: U1.3, U1.4
unnamed: U1.6, U1.12
unnamed: U1.8, U1.13
unnamed: U2.3, U2.4
unnamed: U2.6, U2.12
unnamed: U2.8, U2.13
VCC: C1.1, C2.1, C3.1, F2.1, J2.3, J3.1, J3.3, J4.4, J5.1, R3.1, R4.1, TP2.1, U1.14, U2.14, U3.8
VIN: F1.2, J1.2, J1.4

## KiCad design LED/TSAL_LED.kicad_pcb

Parts:
C101, C102: 100u; CP_Elec_6.3x5.8
H101, H102, H103, H104: MountingHole; MountingHole_3.2mm_M3_DIN965_Pad_TopBottom
J101: Conn_01x04_Male; Molex_SPOX_5267-04A_1x04_P2.50mm_Vertical
R101: TUNE, <100R; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R102: TUNE, <300R; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder

Connections:
/GLED+: J101.1, R101.2
/GLED-: C102.2, J101.2; also elsewhere on the board
/GRN_LEDS/GLED+: C102.1, R101.1; also elsewhere on the board
/RED_LEDS/RLED+: C101.1, R102.1; also elsewhere on the board
/RLED+: J101.3, R102.2
/RLED-: C101.2, J101.4; also elsewhere on the board

Parts:
D301, D302, D303, D304, D305, D306, D307, D308, D309, D310, D311, D312, D313, D314, D315, D316, D317, D318, D319, D320: LED; LED_D5.0mm_Horizontal_O1.27mm_Z3.0mm
R301, R302, R303, R304, R305, R306, R307, R308, R309, R310, R311, R312, R313, R314, R315, R316, R317, R318, R319, R320: 100R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder

Connections:
/RED_LEDS/RLED+: R301.1, R302.1, R303.1, R304.1, R305.1, R306.1, R307.1, R308.1, R309.1, R310.1, R311.1, R312.1, R313.1, R314.1, R315.1, R316.1, R317.1, R318.1, R319.1, R320.1; also elsewhere on the board
/RLED-: D301.1 (K), D302.1 (K), D303.1 (K), D304.1 (K), D305.1 (K), D306.1 (K), D307.1 (K), D308.1 (K), D309.1 (K), D310.1 (K), D311.1 (K), D312.1 (K), D313.1 (K), D314.1 (K), D315.1 (K), D316.1 (K), D317.1 (K), D318.1 (K), D319.1 (K), D320.1 (K); also elsewhere on the board
unnamed: D301.2 (A), R301.2
unnamed: D302.2 (A), R302.2
unnamed: D303.2 (A), R303.2
unnamed: D304.2 (A), R304.2
unnamed: D305.2 (A), R305.2
unnamed: D306.2 (A), R306.2
unnamed: D307.2 (A), R307.2
unnamed: D308.2 (A), R308.2
unnamed: D309.2 (A), R309.2
unnamed: D310.2 (A), R310.2
unnamed: D311.2 (A), R311.2
unnamed: D312.2 (A), R312.2
unnamed: D313.2 (A), R313.2
unnamed: D314.2 (A), R314.2
unnamed: D315.2 (A), R315.2
unnamed: D316.2 (A), R316.2
unnamed: D317.2 (A), R317.2
unnamed: D318.2 (A), R318.2
unnamed: D319.2 (A), R319.2
unnamed: D320.2 (A), R320.2

Parts:
D201, D202, D203, D204, D205, D206, D207, D208, D209, D210, D211, D212, D213, D214, D215, D216, D217, D218, D219, D220: LED; LED_D5.0mm_Horizontal_O1.27mm_Z3.0mm
R201, R202, R203, R204, R205, R206, R207, R208, R209, R210, R211, R212, R213, R214, R215, R216, R217, R218, R219, R220: 33R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder

Connections:
/GLED-: D201.1 (K), D202.1 (K), D203.1 (K), D204.1 (K), D205.1 (K), D206.1 (K), D207.1 (K), D208.1 (K), D209.1 (K), D210.1 (K), D211.1 (K), D212.1 (K), D213.1 (K), D214.1 (K), D215.1 (K), D216.1 (K), D217.1 (K), D218.1 (K), D219.1 (K), D220.1 (K); also elsewhere on the board
/GRN_LEDS/GLED+: R201.1, R202.1, R203.1, R204.1, R205.1, R206.1, R207.1, R208.1, R209.1, R210.1, R211.1, R212.1, R213.1, R214.1, R215.1, R216.1, R217.1, R218.1, R219.1, R220.1; also elsewhere on the board
unnamed: D201.2 (A), R201.2
unnamed: D202.2 (A), R202.2
unnamed: D203.2 (A), R203.2
unnamed: D204.2 (A), R204.2
unnamed: D205.2 (A), R205.2
unnamed: D206.2 (A), R206.2
unnamed: D207.2 (A), R207.2
unnamed: D208.2 (A), R208.2
unnamed: D209.2 (A), R209.2
unnamed: D210.2 (A), R210.2
unnamed: D211.2 (A), R211.2
unnamed: D212.2 (A), R212.2
unnamed: D213.2 (A), R213.2
unnamed: D214.2 (A), R214.2
unnamed: D215.2 (A), R215.2
unnamed: D216.2 (A), R216.2
unnamed: D217.2 (A), R217.2
unnamed: D218.2 (A), R218.2
unnamed: D219.2 (A), R219.2
unnamed: D220.2 (A), R220.2

Board: 2 copper layers, 147.0 x 50.0 mm, 89 parts (0 on the bottom side), 46 nets.

## KiCad design HV_Sense/TSAL_HV_Sense.kicad_pcb

Parts:
D1, D2: 51V; D_DO-41_SOD81_P10.16mm_Horizontal; Part 1N5942B
D3: 33V; D_DO-41_SOD81_P10.16mm_Horizontal; Part 1N5937B
D4, D5, D6: LED; LED_D3.0mm
J1, J3: Micro-Fit; Molex_Micro-Fit_3.0_43650-0215_1x02_P3.00mm_Vertical; Part 43650-0216
J2, J5: Mini-SPOX; Molex_SPOX_5267-03A_1x03_P2.50mm_Vertical; Part 22035035
J4: Mini-SPOX; Molex_SPOX_5267-02A_1x02_P2.50mm_Vertical; Part 22035025
J6: Mini-SPOX; Molex_SPOX_5267-06A_1x06_P2.50mm_Vertical; Part 22035065
R1, R3: 10k; R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal; Part RSMF1JT10K0
R2, R6, R7, R8, R9: 10k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder; Part RC0805FR-0710KL
R4, R5: 2k; R_Axial_DIN0309_L9.0mm_D3.2mm_P12.70mm_Horizontal; Part RSMF1JT2K00
R10, R11, R12: 1k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder; Part RC0805FR-071KL
U1, U2: 4N35; DIP-6_W7.62mm; Part 4N35

Connections:
unnamed: D1.1 (K), J1.2
unnamed: D1.2 (A), R1.2
unnamed: D2.1 (K), D3.1 (K), J3.2
unnamed: D2.2 (A), R3.2
unnamed: D3.2 (A), R4.2
unnamed: D4.1 (K), R10.2
unnamed: D4.2 (A), D5.2 (A), D6.2 (A), J6.4, R6.2, R7.1, R8.1, R9.1
unnamed: D5.1 (K), R11.2
unnamed: D6.1 (K), R12.2
unnamed: J1.1, U1.2
unnamed: J2.1, U1.4
unnamed: J2.2, R2.2, U1.5
unnamed: J2.3, R2.1
unnamed: J3.1, J4.1, U2.2
unnamed: J4.2, R5.1
unnamed: J5.1, J6.3, R9.2, R12.1
unnamed: J5.2, J6.2, R8.2, R11.1
unnamed: J5.3, J6.1, R7.2, R10.1
unnamed: J6.5, U2.4
unnamed: J6.6, R6.1, U2.5
unnamed: R1.1, U1.1
unnamed: R3.1, U2.1
unnamed: R4.1, R5.2

Notes on the sheet:
To Relay Aux
To TSAL Logic Board
To HV Indicator LED
Mechanical dimensions: 40mm x 40mm Mounting holes: M3, 30mm x 30mm
HV Sense Board 1 Located in HV Junction Box
Mechanical dimensions: 50mm x 50mm Mounting holes: M3, 40mm x 40mm
HV Sense Board 2 Located in Battery Power Electronics Compartment
HV+
HV-
VCC
Sense
GND
AUX_3
AUX_2
AUX_1

Board: 2 copper layers, 100.0 x 50.0 mm, 28 parts (8 on the bottom side), 23 nets.

Other parts of the board:
 : MountingHole_3.2mm_M3
 #2: MountingHole_3.2mm_M3

## KiCad design TSAL_LED.kicad_pcb

Parts:
D1, D2, D5, D6, D11, D12, D15, D16, D17, D18, D19, D20: LED_RABG; LED_D5.0mm-4_RGB; Part WP154A4SEJ3VBDZGC/CA
D3, D4, D7, D8, D9, D10, D13, D14: LED_RABG; LED_D5.0mm-4_RGB; Part WP154A4SEJ3VBDZGW/CA
D21: D; d0214ba; Part LSM115JE3/TR13
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3_Pad
J1: Mini-SPOX; Molex_SPOX_5267-04A_1x04_P2.50mm_Vertical; Part 22-03-5045
L2: 4.7uH; L_Coilcraft_LPS5030; Part LTF5022T-4R7N2R0-LC
Q1: Q_PMOS_GSD; SOT-23; Part DMP1045UQ-7
R1, R2, R3, R4, R9, R10, R11, R12, R17, R18, R19, R20, R25, R26, R27, R28, R33, R34, R37, R38: 15R; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R5, R6, R23, R24, R31, R32, R39, R40: DNP; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R7, R8, R13, R14, R15, R16, R21, R22, R29, R30, R35, R36: 39R; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
TP1: TestPoint; TestPoint_Pad_D3.0mm
U2: XC9141; SOT-23-5_HandSoldering; Part XC9141B33CMR-G

Connections:
+2V5: J1.1, J1.3, L2.1, Q1.3, U2.1 (CE), U2.3 (BAT)
/GLED-: J1.4, R5.2, R6.2, R7.2, R8.2, R13.2, R14.2, R15.2, R16.2, R21.2, R22.2, R23.2, R24.2, R29.2, R30.2, R31.2, R32.2, R35.2, R36.2, R39.2, R40.2, U2.2 (GND)
/LED+: D1.2 (A), D2.2 (A), D3.2 (A), D4.2 (A), D5.2 (A), D6.2 (A), D7.2 (A), D8.2 (A), D9.2 (A), D10.2 (A), D11.2 (A), D12.2 (A), D13.2 (A), D14.2 (A), D15.2 (A), D16.2 (A), D17.2 (A), D18.2 (A), D19.2 (A), D20.2 (A), D21.1 (K), Q1.2
/RLED-: J1.2, Q1.1, R1.2, R2.2, R3.2, R4.2, R9.2, R10.2, R11.2, R12.2, R17.2, R18.2, R19.2, R20.2, R25.2, R26.2, R27.2, R28.2, R33.2, R34.2, R37.2, R38.2
unnamed: D1.1 (RK), R1.1
unnamed: D1.4 (GK), R5.1
unnamed: D2.1 (RK), R2.1
unnamed: D2.4 (GK), R6.1
unnamed: D3.1 (RK), R3.1
unnamed: D3.4 (GK), R7.1
unnamed: D4.1 (RK), R4.1
unnamed: D4.4 (GK), R8.1
unnamed: D5.1 (RK), R9.1
unnamed: D5.4 (GK), R13.1
unnamed: D6.1 (RK), R10.1
unnamed: D6.4 (GK), R14.1
unnamed: D7.1 (RK), R11.1
unnamed: D7.4 (GK), R15.1
unnamed: D8.1 (RK), R12.1
unnamed: D8.4 (GK), R16.1
unnamed: D9.1 (RK), R17.1
unnamed: D9.4 (GK), R21.1
unnamed: D10.1 (RK), R18.1
unnamed: D10.4 (GK), R22.1
unnamed: D11.1 (RK), R19.1
unnamed: D11.4 (GK), R23.1
unnamed: D12.1 (RK), R20.1
unnamed: D12.4 (GK), R24.1
unnamed: D13.1 (RK), R25.1
unnamed: D13.4 (GK), R29.1
unnamed: D14.1 (RK), R26.1
unnamed: D14.4 (GK), R30.1
unnamed: D15.1 (RK), R27.1
unnamed: D15.4 (GK), R31.1
unnamed: D16.1 (RK), R28.1
unnamed: D16.4 (GK), R32.1
unnamed: D17.1 (RK), R33.1
unnamed: D17.4 (GK), R35.1
unnamed: D18.1 (RK), R34.1
unnamed: D18.4 (GK), R36.1
unnamed: D19.1 (RK), R37.1
unnamed: D19.4 (GK), R39.1
unnamed: D20.1 (RK), R38.1
unnamed: D20.4 (GK), R40.1
unnamed: D21.2 (A), TP1.1, U2.4 (Vout)
unnamed: L2.2, U2.5 (Lx)

Notes on the sheet:
WP154A4SEJ3VBDZGW/CA 60 deg diffused (low intensity)
WP154A4SEJ3VBDZGC/CA 50 deg clear (high intensity)
Front
Rear

Board: 2 copper layers, 104.1 x 45.8 mm, 70 parts (10 on the bottom side), 46 nets.
