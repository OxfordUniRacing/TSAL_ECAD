# Repository OxfordUniRacing/TSAL_ECAD (continued)

## KiCad design TSAL.kicad_pcb

Parts:
C1, C4: 10u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder; Part GRM21BC81E106KE11
C2, C3, C5, C6: 100n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder; Part CL21B104KACNNNC
C7: 2.2u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder; Part GRM21BR71E225KE11
F1: 1A; Fuseholder_Cylinder-5x20mm_Schurter_0031_8201_Horizontal_Op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; Part 0031.8201
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3_Pad
J1: Mini-SPOX; Molex_SPOX_5267-03A_1x03_P2.50mm_Vertical; Part 22-03-5035
J2: Mini-SPOX; Molex_SPOX_5267-06A_1x06_P2.50mm_Vertical; Part 22-03-5065
J3: Mini-Fit_Jr; Molex_Mini-Fit_Jr_5566-02A_2x01_P4.20mm_Vertical; Part 39-28-1023
J4: Mini-SPOX; Molex_SPOX_5267-04A_1x04_P2.50mm_Vertical; Part 22-03-5045
J5: Mini-SPOX; Molex_SPOX_5267-02A_1x02_P2.50mm_Vertical; Part 22-03-5025
Q1, Q2, Q3, Q4: IRLML2502; SOT-23_Handsoldering; Part IRLML2502TRPBF
R1, R2, R6, R7, R15, R16, R17, R18, R19: 100k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder; Part RC0805FR-07100KL
R3, R5: 22k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder; Part RC0805FR-0722KL
R4: 1k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder; Part RC0805FR-071KL
TP1: TP_Timer_En; TestPoint_THTPad_D2.0mm_Drill1.0mm
TP2: TP_RLED_Ctrl; TestPoint_THTPad_D2.0mm_Drill1.0mm
U1, U2: 74HC08; SOIC-14_3.9x8.7mm_P1.27mm; Part SN74HC08DR
U3: TLV70033; SOT-23-5_HandSoldering; Part TLV70033DDCR
U4: LMC555; SOIC-8_3.9x4.9mm_P1.27mm; Part LMC555CMX

Connections:
+2V5: J4.1, J4.3; also elsewhere on the board
/AUX_1: J2.4, R17.1, U1.5, U2.5
/AUX_2: J2.5, R18.1, U1.10, U2.9
/AUX_3: J2.6, R19.1, U1.9, U2.10
/GLED-: J4.4, Q1.3 (D)
/RLED-: J4.2, Q4.3 (D)
/Sense_1: J1.2, R15.1, U1.1, U2.1
/Sense_2: J2.3, R16.1, U1.2, U2.2
/TS_Inact_Out: C4.1, J5.1, U3.5 (OUT)
/VCC_F: F1.1, J1.1, J2.1
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, J1.3, J2.2, J3.2, J5.2, Q2.2 (S), Q3.2 (S), Q4.2 (S), R1.2, R2.2, R7.2, R15.2, R16.2, R17.2, R18.2, R19.2, U1.7 (GND), U2.7 (GND), U3.2 (GND), U4.1 (GND); also elsewhere on the board
unnamed: C6.1, U4.5 (CV)
unnamed: C7.1, R6.2, U4.2 (TR), U4.6 (THR)
unnamed: Q1.1 (G), R1.1, U1.11
unnamed: Q1.2 (S), Q2.3 (D)
unnamed: Q2.1 (G), Q3.1 (G), R2.1, U2.11, U3.3 (EN)
unnamed: Q3.3 (D), R3.2, R4.2
unnamed: Q4.1 (G), R7.1, TP2.1, U4.3 (Q)
unnamed: R4.1, TP1.1, U4.4 (R)
unnamed: R5.2, R6.1, U4.7 (DIS)
unnamed: U1.3, U1.4
unnamed: U1.6, U1.12
unnamed: U1.8, U1.13
unnamed: U2.3, U2.4
unnamed: U2.6, U2.12
unnamed: U2.8, U2.13
VCC: C1.1, C2.1, C3.1, C5.1, F1.2, R3.1, R5.1, U1.14 (VCC), U2.14 (VCC), U3.1 (IN), U4.8 (VCC); also elsewhere on the board
VIN: J3.1; also elsewhere on the board

Notes on the sheet:
3Hz 55% duty cycle
High signals = TS inactive

Parts:
C9: 100u; CP_Radial_D5.0mm_P2.50mm; Part UVY1E101MDD1TD
C10, C13, C14, C15, C22, C23: 10u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder; Part GRM21BC81E106KE11
C11, C12: 100n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder; Part CL21B104KACNNNC
C16, C17, C18, C19: 35; CP_Radial_D16.0mm_P7.50mm; Part SCCU30B356SRB
C20, C21: DNP; CP_Radial_D16.0mm_P7.50mm
D1: SMF4L15A; D_SOD-123_HandSolder; Part SMF4L15A
D2: FSV1045V; TO-277A_HandSolder; Part FSV1045V
D3: S1A; D_SMA_Handsoldering; Part S1A
F2: 3A; Fuseholder_Cylinder-5x20mm_Schurter_0031_8201_Horizontal_Op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; Part 0031.8201
J6, J7: Jumper; PinHeader_1x02_P2.54mm_Vertical
JP1: Jumper; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
L1: 15u; 104CDMCCDS; Part 104CDMCCDS-150MC
L2: 10u; CDRH62B; Part CDRH62BNP-100MC-B
Q5: IRF8721; SOIC-8_3.9x4.9mm_P1.27mm; Part IRF8721TRPBF
R8, R14: 100k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder; Part RC0805FR-07100KL
R9: 22k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder; Part RC0805FR-0722KL
R10: 130k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder; Part RC0805FR-07130KL
R11: 1k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder; Part RC0805FR-071KL
R12: 4.7; R_Axial_DIN0516_L15.5mm_D5.0mm_P20.32mm_Horizontal; Part AC03000004708JAC00
R13: 820k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder; Part RC0805FR-07820KL
TP3: TP_VCC; TestPoint_THTPad_D2.0mm_Drill1.0mm
TP4: TP_2V5; TestPoint_THTPad_D2.0mm_Drill1.0mm
TP5: TP_Vcap; TestPoint_THTPad_D2.0mm_Drill1.0mm
TP6: TP_Vmid; TestPoint_THTPad_D2.0mm_Drill1.0mm
TP7: TP_GND; TestPoint_THTPad_D2.0mm_Drill1.0mm
U5: LMR14030; SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.41x3.3mm; Part LMR14030SDDAR
U6: ZLDO1117G50; SOT-223-3_TabPin2; Part ZLDO1117G50TA
U7: TPS62205; SOT-23-5_HandSoldering; Part TPS62205DBVR
U8: MAX40200AUK; SOT-23-5_HandSoldering; Part MAX40200AUK+T

Connections:
+2V5: C23.1, L2.2, TP4.1, U7.4 (FB); also elsewhere on the board
/Power/VIN_F: C9.1, C10.1, C13.1, D1.1 (K), F2.1, Q5.4 (G), R13.1, U5.2 (VIN), U6.3 (VI)
/Power/Vcap: C16.1, C18.1, C20.1, J7.2, JP1.2 (B), R12.1, TP5.1, U8.1 (VDD), U8.3 (EN)
GND: C9.2, C10.2, C11.2, C13.2, C14.2, C15.2, C17.2, C19.2, C21.2, C22.2, C23.2, D1.2 (A), D2.1 (A), D2.2 (A), J6.2, R8.2, R9.2, R11.2, R14.2, TP7.1, U5.7 (GND), U5.9 (EP), U6.1 (GND), U7.2 (GND), U8.2 (GND); also elsewhere on the board
unnamed: C11.1, U5.6 (SS)
unnamed: C12.1, U5.1 (BOOT)
unnamed: C12.2, D2.3 (K), L1.1, U5.8 (SW)
unnamed: C14.1, L1.2, Q5.1 (S), Q5.2 (S), Q5.3 (S), R10.1
unnamed: C15.1, D3.2 (A), R11.1, U6.2 (VO)
unnamed: C16.2, C17.1, C18.2, C19.1, C20.2, C21.1, TP6.1
unnamed: J6.1, R12.2
unnamed: J7.1, JP1.1 (A), Q5.5 (D), Q5.6 (D), Q5.7 (D), Q5.8 (D)
unnamed: L2.1, U7.5 (SW)
unnamed: R8.1, U5.4 (RT/SYNC)
unnamed: R9.1, R10.2, U5.5 (FB)
unnamed: R13.2, R14.1, U5.3 (EN)
VCC: C22.1, D3.1 (K), TP3.1, U7.1 (VI), U7.3 (EN), U8.5 (OUT); also elsewhere on the board
VIN: F2.2; also elsewhere on the board

Notes on the sheet:
Energy Storage
Discharge
2.5-5.2V operating
10-15V
250kHz switching frequency
5.2V output
SCCU30B356SRB
Current Measure
UVLO 10V

Board: 2 copper layers, 140.0 x 70.0 mm, 80 parts (0 on the bottom side), 42 nets.

## Commit log

2019-12-10 initial import
2019-12-14 schematics
2020-01-18 change to ideal diode controller
2020-01-27 last minute changes to test points and routing
2020-01-27 Rev A gerbers
2020-02-09 added LED board
2020-02-09 remove boost converter for RLED
2020-02-10 Redo HV sense boards
    - added circuitry & connector for ts active led
    - added led indicators for relay aux
2020-02-10 hv sense: include mechanical info in schematics
2020-02-12 shuffled some files around, generated gerbers
2020-02-19 tsal sense board update
    hopefully last update
2020-02-19 use outline layer for cutout
2020-02-19 oops obsolete part
2021-02-07 re-organize files
2021-02-10 Added new design of TSAL LED board
2021-02-18 HV_Sense: change hv input connector to Micro-Fit
2021-02-18 HV_Sense: update schematics
2021-02-22 Main board: Rev B schematics design
    major redesign of power delivery and backup
2021-02-22 Main board; tweak feedback compensation network
2021-02-23 Main board: final change to compensation network
    None of this really matters with the supercaps at the output,
    just trying to optimize the loop without them.
2021-02-23 Add simulation of compensation network design
2021-02-23 Move LED board files
2021-02-24 Added first rev of design of new TSAL main board
2021-02-25 LED board: fix connector 3d model
2021-02-28 Main: optimized layout
2021-02-28 Main: fix rescue symbols
2021-03-01 Main: update sot23-5/6 footprints
    Bloody kicad libaries
2021-03-01 Main: archive symbols and footprints
    Kicad library management is really terrible.
    This is pulled together with janky scripts and sed.
2021-03-01 Main board rev b release?
2021-03-01 kicad please I wanted solid gnd connections
2021-03-08 increase output filter capacitor value
2021-06-01 Fixed LMC555 footprint error on main TSAL board
2021-11-17 Updated to version that was ordered
2022-04-25 hv sense v2
